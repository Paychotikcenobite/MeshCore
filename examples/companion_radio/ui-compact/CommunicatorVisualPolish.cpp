#include "CommunicatorAppScreen.h"

namespace {

// 24x24, 4-bit alpha masks. Settings is rasterized from Microsoft's Fluent
// Settings 24 regular geometry; Wi-Fi uses the same Windows/Fluent fan idiom.
// Two alpha samples are packed per byte (high nibble first). 4-bit coverage is
// enough to eliminate the stair-stepped single-pixel look on the 320x240 TFT.
static const uint8_t WIFI24_A4[288] = {
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0x69,0xBB,0xBB,0x96,0x30,0x00,0x00,0x00,
  0x00,0x00,0x28,0xDF,0xFF,0xFF,0xFF,0xFF,0xFD,0x82,0x00,0x00,0x00,0x07,0xFF,0xE8,
  0x52,0x11,0x11,0x25,0x8E,0xFF,0x70,0x00,0x03,0xCF,0xC5,0x10,0x00,0x00,0x00,0x00,
  0x01,0x5C,0xFC,0x30,0x5F,0xF7,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x7F,0xE5,
  0xFE,0x30,0x00,0x00,0x48,0xBB,0xBB,0x84,0x00,0x00,0x03,0xEF,0xE3,0x00,0x00,0x6D,
  0xFF,0xFF,0xFF,0xFF,0xD6,0x00,0x00,0x3E,0x40,0x00,0x3C,0xFC,0x73,0x11,0x11,0x37,
  0xCF,0xC3,0x00,0x04,0x00,0x04,0xFF,0x60,0x00,0x00,0x00,0x00,0x06,0xFF,0x40,0x00,
  0x00,0x4F,0xE3,0x00,0x00,0x00,0x00,0x00,0x00,0x3E,0xF4,0x00,0x00,0x3C,0x40,0x00,
  0x05,0xAB,0xBA,0x50,0x00,0x04,0xC3,0x00,0x00,0x00,0x00,0x03,0xCF,0xFF,0xFF,0xFC,
  0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xF8,0x21,0x12,0x8F,0xF4,0x00,0x00,0x00,
  0x00,0x00,0x00,0x6F,0x50,0x00,0x00,0x05,0xF6,0x00,0x00,0x00,0x00,0x00,0x00,0x02,
  0x00,0x18,0x81,0x00,0x20,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x8F,0xF8,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x8F,0xF8,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x18,0x81,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00
};

static const uint8_t SETTINGS24_A4[288] = {
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x04,0x9C,0xC9,0x40,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0D,0xFC,0xCF,0xD0,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x0E,0x90,0x09,0xE0,0x00,0x00,0x00,0x00,0x00,0x00,0x4C,0x72,
  0x6F,0x60,0x05,0xF6,0x27,0xC4,0x00,0x00,0x00,0x02,0xEE,0xFF,0xFA,0x10,0x01,0xAF,
  0xFF,0xEE,0x20,0x00,0x00,0x0A,0xF2,0x26,0x40,0x00,0x00,0x04,0x62,0x2F,0xA0,0x00,
  0x00,0x2F,0x80,0x00,0x00,0x6B,0xB6,0x00,0x00,0x08,0xF2,0x00,0x00,0x4F,0xB1,0x00,
  0x1B,0xFD,0xDF,0xB1,0x00,0x1B,0xF4,0x00,0x00,0x06,0xFC,0x00,0x6F,0x60,0x06,0xF6,
  0x00,0xCF,0x60,0x00,0x00,0x00,0x5F,0x30,0xCD,0x00,0x00,0xDB,0x03,0xF6,0x00,0x00,
  0x00,0x00,0x5F,0x30,0xBD,0x00,0x00,0xDB,0x03,0xF6,0x00,0x00,0x00,0x06,0xFC,0x00,
  0x6F,0x60,0x06,0xF6,0x00,0xCF,0x60,0x00,0x00,0x4F,0xB1,0x00,0x1B,0xFD,0xDF,0xB1,
  0x00,0x1B,0xF4,0x00,0x00,0x2F,0x80,0x00,0x00,0x6B,0xB6,0x00,0x00,0x08,0xF2,0x00,
  0x00,0x0A,0xF2,0x26,0x40,0x00,0x00,0x04,0x62,0x2F,0xA0,0x00,0x00,0x02,0xEE,0xFF,
  0xFA,0x10,0x01,0xAF,0xFF,0xEE,0x20,0x00,0x00,0x00,0x4C,0x72,0x6F,0x60,0x06,0xF6,
  0x27,0xC4,0x00,0x00,0x00,0x00,0x00,0x00,0x0E,0x90,0x09,0xE0,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x0D,0xFC,0xCF,0xD0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x04,0x9C,0xC9,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00
};

ColorVal blend565(ColorVal fg, ColorVal bg, uint8_t a4) {
  if (a4 == 0) return bg;
  if (a4 >= 15) return fg;
  uint16_t fr=(fg>>11)&31, fg6=(fg>>5)&63, fb=fg&31;
  uint16_t br=(bg>>11)&31, bg6=(bg>>5)&63, bb=bg&31;
  uint16_t r=(fr*a4+br*(15-a4)+7)/15;
  uint16_t g=(fg6*a4+bg6*(15-a4)+7)/15;
  uint16_t b=(fb*a4+bb*(15-a4)+7)/15;
  return (ColorVal)((r<<11)|(g<<5)|b);
}

ColorVal darken565(ColorVal c, uint8_t amount) {
  uint16_t r=(c>>11)&31, g=(c>>5)&63, b=c&31;
  r=(r*(255-amount))/255; g=(g*(255-amount))/255; b=(b*(255-amount))/255;
  return (ColorVal)((r<<11)|(g<<5)|b);
}

ColorVal lighten565(ColorVal c, uint8_t amount) {
  uint16_t r=(c>>11)&31, g=(c>>5)&63, b=c&31;
  r += ((31-r)*amount)/255; g += ((63-g)*amount)/255; b += ((31-b)*amount)/255;
  return (ColorVal)((r<<11)|(g<<5)|b);
}

uint8_t alphaAt(const uint8_t* mask, int pixel) {
  uint8_t v = mask[pixel >> 1];
  return (pixel & 1) ? (v & 0x0F) : (v >> 4);
}

void drawAlphaMask4(DisplayDriver& d, int x, int y, const uint8_t* mask,
                    int w, int h, ColorVal fg, ColorVal bg) {
  for (int yy=0; yy<h; ++yy) {
    int xx=0;
    while (xx<w) {
      uint8_t a=alphaAt(mask, yy*w+xx);
      if (!a) { ++xx; continue; }
      if (a==15) {
        int start=xx;
        while (xx<w && alphaAt(mask, yy*w+xx)==15) ++xx;
        d.setColor(fg); d.fillRect(x+start,y+yy,xx-start,1);
        continue;
      }
      d.setColor(blend565(fg,bg,a)); d.fillRect(x+xx,y+yy,1,1);
      ++xx;
    }
  }
}

} // namespace

void CommunicatorAppScreen::redrawHeaderActionIconsFluent(DisplayDriver& d) {
  const ColorVal bg = _light_mode ? (ColorVal)0xF7DF : (ColorVal)0x0084;
  const ColorVal card = _light_mode ? (ColorVal)0xFFFF : (ColorVal)0x08E6;
  const ColorVal divider = _light_mode ? (ColorVal)0xDED7 : (ColorVal)0x29CF;
  const ColorVal text = _light_mode ? (ColorVal)0x14E5 : (ColorVal)0xFFFF;
  const ColorVal radioOk = _light_mode ? (ColorVal)0x246B : (ColorVal)0x25CB;
  const ColorVal shadow = darken565(bg, 110);
  const ColorVal highlight = lighten565(card, _light_mode ? 24 : 18);

  // Soft one-pixel shadow + bright top edge gives the header controls depth
  // without turning the compact UI into skeuomorphism.
  d.setColor(shadow); d.fillRoundRect(238,5,36,33,7); d.fillRoundRect(279,5,36,33,7);
  d.setColor(card); d.fillRoundRect(238,3,36,33,7); d.fillRoundRect(279,3,36,33,7);
  d.setColor(divider); d.drawRoundRect(238,3,36,33,7); d.drawRoundRect(279,3,36,33,7);
  d.setColor(highlight); d.drawLine(246,4,266,4); d.drawLine(287,4,307,4);

  drawAlphaMask4(d,244,7,WIFI24_A4,24,24,text,card);
  drawAlphaMask4(d,285,7,SETTINGS24_A4,24,24,text,card);

  // Keep radio health separate from the glyph itself. This lets the icon stay
  // visually Windows-like instead of coloring the entire Wi-Fi fan green.
  d.setColor(radioOk); d.fillCircle(269,31,2);
  d.setColor(text);
}
